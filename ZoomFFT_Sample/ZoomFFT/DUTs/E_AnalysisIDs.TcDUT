TYPE E_AnalysisIDs :
(
	(* analysis chain *)
	eID_Source := 1,
	eID_FFT,
	eID_ZoomFFT,
	eID_SinkFFT,
	eID_SinkZoomFFT
	
) UDINT;
END_TYPE
